v {xschem version=3.4.8RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
